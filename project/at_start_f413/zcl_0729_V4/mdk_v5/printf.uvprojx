# Keil uVision project printf.uvprojx, settings and files
target RHINO-Pro_bldc (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F413CCU7 ArteryTek
  pack: ArteryTek.AT32F413_DFP.2.1.8
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RHINO-Pro_bldc +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin --output .\objects\bin\RHINO-Pro_bldc.bin .\objects\RHINO-Pro_bldc.axf
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: AT32F413CCU7,USE_STDPERIPH_DRIVER,AT_START_F413_V1,AT_START_F413_V1,__CC_ARM,__TARGET_FPU_VFP,__FPU_PRESENT =1U ,ARM_MATH_CM4,DRIVE_BOARD
  c include: ..\FreeRTOS;..\FreeRTOS\Source;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\libraries;..\..\..\..\libraries\drivers\src;..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\dsp;..\..\zcl_0729_V4;..\middle_port;..\inc;..\at32f413_board;..\motor;..\motor_app;..\tool;..\src;..\..\..\..\libraries\drivers\src;..\..\..\..\libraries\drivers\inc;.\lib;..\..\..\..\libraries\cmsis\cm4\device_support\startup\mdk;..\..\..\..\libraries\cmsis\cm4\device_support;..\thread;.\objects;.\listings;..\FreeRTOS\Source\include;..\tool\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c at32f413_clock.c at32f413_int.c
    ./lib/: MPS_eMotion_Lib.lib
  group bsp（HDL+FML）
    ../at32f413_board/: time_init.c wdt.c at32f413_board.c
    ../middle_port/: oled_port.c gpio_port.c adc_port.c buzz_port.c key.c usart_port.c apex_gc_port.c app_queue.c BLE_2340C2.c
    ../src/: flash.c
  group thread（APL）
    ../thread/: main_thread.c app_PeriodicTask.c app_MotorControlTask.c app_MenuTask.c app_user_storage.c
  group cmsis
    ./: startup_at32f413_ext_ram.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f413.c
    ../../../../libraries/cmsis/dsp/Lib/ARM/: arm_cortexM4lf_math.lib
  group Motor_app（FML）
    ../motor_app/: mp6570.c customer_control.c delay.c
  group FreeRTOS
    ../FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group portRTOS
    ../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_2.c
  group SEEGER_RTT
    ../tool/RTT/: SEGGER_RTT_printf.c SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
  group firmware
    ../../../../libraries/drivers/src/: at32f413_acc.c at32f413_adc.c at32f413_bpr.c at32f413_can.c at32f413_crc.c at32f413_crm.c at32f413_debug.c at32f413_dma.c at32f413_exint.c at32f413_flash.c at32f413_gpio.c at32f413_i2c.c at32f413_misc.c at32f413_pwc.c at32f413_rtc.c at32f413_sdio.c at32f413_spi.c at32f413_tmr.c at32f413_usart.c at32f413_usb.c at32f413_wdt.c at32f413_wwdt.c
software components: CMSIS:CORE 6.1.0
